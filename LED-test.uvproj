# Keil uVision project LED-test.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H4K64TLR Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x0FFF) IROM(0-0xFFF8) CLOCK(45000000) MODP2
  output: LED-test +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: isr.asm LED-8x8A-8x8B.c RTC.c Display.c Touch.c Mode.c Beep.c Uart.c Temperature.c Clock.c Time.c Adc.c Sound.c
